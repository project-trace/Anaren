# IAR project HAL Helper.ewp, settings and files
configuration MDB1 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F248 MSP430F248
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MDB1; ZM_PHY_SPI
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F248.xcl
  XLINK.XlinkStackSize: 1
configuration LaunchPad (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  ICC430.CCDefines: LAUNCHPAD
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
configuration FRAM (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  ICC430.CCDefines: FRAM
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  group (top)
    ../: hal_fram.c hal_helper.c hal_launchpad.c hal_mdb1.c hal_msp430x2xxx_oscillators.c hal_msp430x2xxx_usci.c
    ../../Common/: printf.c
