# IAR project Range Test - Router.ewp, settings and files
configuration MDB2 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DISPLAY_NETWORK_INFORMATION; MDB2; ZM_PHY_SPI
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F5133.xcl
  XLINK.XlinkStackSize: 1
configuration MDB1 (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F248 MSP430F248
  ICC430.CCDefines: MDB1; USE_STDIO; GET_NETWORK_CONFIGURATION_PARAMETERS
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZNP; ../HAL; ../Common
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F248.xcl
configuration Launchpad (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  ICC430.CCDefines: DISPLAY_NETWORK_INFORMATION; LAUNCHPAD; ZM_PHY_SPI
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  group (top)
    ../: example_range_test_router.c module_example_utils.c
  group Common
    ../../Common/: printf.c utilities.c
  group HAL
    ../../HAL/: hal_launchpad.c hal_mdb1.c hal_mdb2.c
  group ZM
    ../../ZM/: af.c application_configuration.c module.c module_errors.c module_utilities.c zdo.c zm_phy_spi.c
