# IAR project Network Explorer.ewp, settings and files
configuration Launchpad (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 100
  General.GHeapSize2: 30
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: LAUNCHPAD; ZM_PHY_SPI; REGION_NORTH_AMERICA; USE_STDIO; MODULE_INTERFACE_VERBOSE; VERBOSE_ERROR_HANDLING; ZM_PHY_SPI_VERBOSE_ERRORS
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -Omsp430_txt
configuration FRAM (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: FRAM; ZM_PHY_SPI
configuration MDB1 (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F248 MSP430F248
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: MDB1; ZM_PHY_SPI
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F248.xcl
configuration MDB1-UART (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F248 MSP430F248
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: MDB1; ZM_PHY_UART; xZM_PHY_UART_VERBOSE; VERBOSE_ERROR_HANDLING
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F248.xcl
  group (top)
    ../: example_network_explorer.c module_example_utils.c
  group Common
    ../../Common/: printf.c utilities.c
  group HAL
    ../../HAL/: hal_fram.c hal_launchpad.c hal_mdb1.c hal_msp430x2xxx_oscillators.c hal_msp430x2xxx_usci.c
  group Messages
    ../Messages/: header.c infoMessage.c
  group ZM
    ../../ZM/: af.c application_configuration.c module.c module_errors.c module_utilities.c zdo.c zm_phy_spi.c zm_phy_uart.c
