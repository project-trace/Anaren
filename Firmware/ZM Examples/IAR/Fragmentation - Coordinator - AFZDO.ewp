# IAR project Fragmentation - Coordinator - AFZDO.ewp, settings and files
configuration MDB1 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F248 MSP430F248
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DISPLAY_NETWORK_INFORMATION; MDB1; USE_STDIO
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZNP; ../HAL; ../Common
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F248.xcl
  XLINK.XlinkStackSize: 1
configuration Launchpad (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  ICC430.CCDefines: LAUNCHPAD; ZM_PHY_SPI; REGION_NORTH_AMERICA; xDISPLAY_NETWORK_INFORMATION
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  group (top)
    ../: example_fragmentation_coordinator_afzdo.c
  group Common
    ../../Common/: printf.c utilities.c
  group HAL
    ../../HAL/: hal_launchpad.c hal_mdb1.c
  group ZM
    ../../ZM/: af.c application_configuration.c module.c module_errors.c module_utilities.c zdo.c zm_phy_spi.c
    ../: module_example_utils.c
