# IAR project Reset Module.ewp, settings and files
configuration MDB1 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F248 MSP430F248
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ZM_PHY_SPI; MDB1
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZNP; ../HAL; ../Common
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F248.xcl
  XLINK.XlinkStackSize: 1
configuration Launchpad (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  ICC430.CCDefines: LAUNCHPAD; ZM_PHY_SPI; xMODULE_INTERFACE_VERBOSE
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
configuration MDB1-UART (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MDB1; ZM_PHY_UART
  group (top)
    ../: example_reset_module.c
  group Common
    ../../Common/: printf.c utilities.c
  group HAL
    ../../HAL/: hal_launchpad.c hal_mdb1.c hal_msp430x2xxx_oscillators.c hal_msp430x2xxx_usci.c
  group ZM
    ../../ZM/: module.c module_errors.c zm_phy_spi.c zm_phy_uart.c
