# IAR project Hello World.ewp, settings and files
configuration MDB2 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MDB2; ZM_PHY_SPI
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration MDB1 (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F248 MSP430F248
  ICC430.CCDefines: MDB1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F248.xcl
configuration Launchpad (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  ICC430.CCDefines: LAUNCHPAD
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
configuration FRAM (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 160
  General.GHeapSize2: 160
  ICC430.CCDefines: FRAM
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5739.xcl
  group (top)
    ../: example_hello_world.c
  group Common
    ../../Common/: printf.c
  group HAL
    ../../HAL/: hal_fram.c hal_launchpad.c hal_mdb1.c hal_mdb2.c hal_msp430x2xxx_oscillators.c hal_msp430x2xxx_usci.c
